# Keil uVision project ts_cafe.uvprojx, settings and files
target nrf52832 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nrf52 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD NRF52_PAN_53 NRF52_PAN_15 NRF52_PAN_54 NRF52_PAN_20 NRF52_PAN_55 NRF52_PAN_30 NRF52_PAN_58 NRF52_PAN_31 NRF52_PAN_62 NRF52_PAN_36 NRF52_PAN_63 NRF52_PAN_51 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BOARD_PCA10040 NRF52_PAN_12 S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: .\app\source;.\app\inc;..\..\common\inc;..\..\common
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x65000
  memory RVCT9: RAM 0x20001f00 size 0x6100
  group Application
    ./app/src/: timeslot.c sys_event.c main.c
    ../../common/src/: aes_app.c ble_app.c cafe.c cli.c custom_ble_services.c simple_uart.c uart_app.c
  group BSP
    ../../common/src/: bbn_board.c
  group Documentation
    ../../../: Abstract.txt license.txt
software components: CMSIS:CORE 4.3.0, Board Support:bsp 11.0.0-2.alpha, Device:Startup 8.3.1, nRF_BLE:BLE_Modules:ble_advdata 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_advertising 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_common 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_conn_params 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_service_common 4.0.0-2.alpha, nRF_BLE:BLE_Modules:device_manager 4.0.0-2.alpha, nRF_Drivers:app_uart 4.0.0-2.alpha, nRF_Drivers:ble_flash 4.0.0-2.alpha, nRF_Drivers:nrf_delay 4.0.0-2.alpha, nRF_Drivers:nrf_drv_common 4.0.0-2.alpha, nRF_Drivers:nrf_drv_gpiote 4.0.0-2.alpha, nRF_Drivers:nrf_drv_uart 4.0.0-2.alpha, nRF_Drivers:nrf_error 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:nrf_gpiote 4.0.0-2.alpha, nRF_Drivers:nrf_soc 4.0.0-2.alpha, nRF_Drivers:nrf_timer 4.0.0-2.alpha, nRF_Drivers:nrf_uart 4.0.0-2.alpha, nRF_Drivers:nrf_uarte 4.0.0-2.alpha, nRF_Drivers:pstorage 4.0.0-2.alpha, nRF_Libraries:app_button 4.0.0-2.alpha, nRF_Libraries:app_error 4.0.0-2.alpha, nRF_Libraries:app_fifo 4.0.0-2.alpha, nRF_Libraries:app_timer 4.0.0-2.alpha, nRF_Libraries:app_trace 4.0.0-2.alpha, nRF_Libraries:app_util 4.0.0-2.alpha, nRF_Libraries:nordic_common 4.0.0-2.alpha, nRF_Libraries:nrf_assert 4.0.0-2.alpha, nRF_Libraries:nrf_log 4.0.0-2.alpha, nRF_Libraries:retarget 4.0.0-2.alpha, nRF_Libraries:segger_rtt 1.2.1-2.alpha, nRF_SoftDevice:Internal:sd_common 2.0.0-2.alpha, nRF_SoftDevice:Internal:softdevice_present 2.0.0-2.alpha, nRF_SoftDevice:s132 2.0.0-7.alpha
