# Keil uVision project ccm_module.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ccm_module
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.0.2, Device:Startup 8.17.0, nRF_Drivers:app_uart 4.0.0-2.alpha, nRF_Drivers:nrf_delay 4.0.0-2.alpha, nRF_Drivers:nrf_drv_common 4.0.0-2.alpha, nRF_Drivers:nrf_drv_uart 4.0.0-2.alpha, nRF_Drivers:nrf_error 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:nrf_uart 4.0.0-2.alpha, nRF_Drivers:nrf_uarte 4.0.0-2.alpha, nRF_Libraries:app_error 4.0.0-2.alpha, nRF_Libraries:app_fifo 4.0.0-2.alpha, nRF_Libraries:app_timer 4.0.0-2.alpha, nRF_Libraries:app_util 4.0.0-2.alpha, nRF_Libraries:nordic_common 4.0.0-2.alpha, nRF_Libraries:nrf_assert 4.0.0-2.alpha, nRF_SoftDevice:Internal:sd_common 2.0.0-2.alpha, nRF_SoftDevice:Internal:softdevice_present 2.0.0-2.alpha, nRF_SoftDevice:s120 2.1.1
