# Keil uVision project cafe_prx.uvprojx, settings and files
target nrf51822_xxac_s130 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51422_xxac_s130 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BBN_BOARD_PINS SLAVE_MODE S130 NRF51822   BLE_STACK_SUPPORT_REQD S132 BOARD_NRF6310 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c misc: --c99
  c include: ..\arm5;.\app\source;..\..\..\common;..\..\..\common\inc;.\app\inc;..\..\..\..\common\inc
  asm define: BLE_STACK_SUPPORT_REQD S130 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x40000
  memory RVCT9: RAM 0x20001f00 size 0x8000
  group Application
    ./app/src/: main.c
    ../../../common/src/: cli.c ws_timer.c ws_uart.c accelerometer_i2c.c ws_adc.c ws_aes.c private_radio.c
  group bsp
    ../../../common/src/: bbn_board.c
target flash_s130_nrf51_1.0.0_softdevice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: as above
  output: s130_nrf51_1.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  asm define: BLE_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target nrf51822_xxac_s132 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.1
  cpu: as above
  output: nrf51422_xxac_s130 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: SLAVE2 BBN_BOARD_PINS SLAVE_MODE  NRF51822 BOARD_NRF6310   BLE_STACK_SUPPORT_REQD S130 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c misc: --c99
  c include: as above
  asm define: BLE_STACK_SUPPORT_REQD S130 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x40000
  memory RVCT9: RAM 0x20001f00 size 0x8000
software components: CMSIS:CORE 5.1.2, CMSIS:CORE 4.3.0, Board Support:bsp 11.0.0-2.alpha, Device:Startup 8.3.1, Device:Startup 8.17.0, nRF_BLE:BLE_Modules:ble_service_common 4.0.0-2.alpha, nRF_Drivers:app_uart 4.0.0-2.alpha, nRF_Drivers:ble_flash 4.0.0-2.alpha, nRF_Drivers:nrf_adc 4.0.0-2.alpha, nRF_Drivers:nrf_delay 4.0.0-2.alpha, nRF_Drivers:nrf_drv_common 4.0.0-2.alpha, nRF_Drivers:nrf_drv_gpiote 4.0.0-2.alpha, nRF_Drivers:nrf_drv_timer 4.0.0-2.alpha, nRF_Drivers:nrf_drv_twi 4.0.0-2.alpha, nRF_Drivers:nrf_drv_uart 4.0.0-2.alpha, nRF_Drivers:nrf_error 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:nrf_gpiote 4.0.0-2.alpha, nRF_Drivers:nrf_timer 4.0.0-2.alpha, nRF_Drivers:nrf_twi 4.0.0-2.alpha, nRF_Drivers:nrf_uart 4.0.0-2.alpha, nRF_Drivers:nrf_uarte 4.0.0-2.alpha, nRF_Drivers:pstorage 4.0.0-2.alpha, nRF_Libraries:app_button 4.0.0-2.alpha, nRF_Libraries:app_error 4.0.0-2.alpha, nRF_Libraries:app_fifo 4.0.0-2.alpha, nRF_Libraries:app_timer 4.0.0-2.alpha, nRF_Libraries:app_twi 4.0.0-2.alpha, nRF_Libraries:app_util 4.0.0-2.alpha, nRF_Libraries:nordic_common 4.0.0-2.alpha, nRF_Libraries:nrf_assert 4.0.0-2.alpha, nRF_Libraries:retarget 4.0.0-2.alpha, nRF_Libraries:segger_rtt 1.2.1-2.alpha, nRF_SoftDevice:Internal:sd_common 2.0.0-2.alpha, nRF_SoftDevice:Internal:softdevice_present 2.0.0-2.alpha, nRF_SoftDevice:s130 2.0.0-7.alpha, nRF_SoftDevice:s132 2.0.0-7.alpha
