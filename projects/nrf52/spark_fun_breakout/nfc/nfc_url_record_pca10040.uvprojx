# Keil uVision project nfc_url_record_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BSP_DEFINES_ONLY NRF52_PAN_53 NRF52_PAN_15 NRF52_PAN_54 NRF52_PAN_20 NRF52_PAN_55 NRF52_PAN_30 NRF52_PAN_58 NRF52_PAN_31 NRF52_PAN_62 NRF52_PAN_36 NRF52_PAN_63 NRF52_PAN_51 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BOARD_PCA10040 NRF52_PAN_12 NRF52 NRF_LOG_USES_UART=1
  c misc: --c99
  c include: ..\..
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../: main.c
  group Documentation
    ../../: Abstract.txt license.txt
target nrf52832_xxab (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: as above
  c misc: --c99
  c include: ..\..
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0, Board Support:bsp 11.0.0-2.alpha, Device:Startup 8.17.0, Device:StartupConfig 8.17.0, nRF_Drivers:app_uart 4.0.0-2.alpha, nRF_Drivers:nrf_clock 4.0.0-2.alpha, nRF_Drivers:nrf_drv_clock 4.0.0-2.alpha, nRF_Drivers:nrf_drv_common 4.0.0-2.alpha, nRF_Drivers:nrf_drv_uart 4.0.0-2.alpha, nRF_Drivers:nrf_error 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:nrf_soc 4.0.0-2.alpha, nRF_Drivers:nrf_uart 4.0.0-2.alpha, nRF_Drivers:nrf_uarte 4.0.0-2.alpha, nRF_Libraries:app_error 4.0.0-2.alpha, nRF_Libraries:app_trace 4.0.0-2.alpha, nRF_Libraries:app_util 4.0.0-2.alpha, nRF_Libraries:nordic_common 4.0.0-2.alpha, nRF_Libraries:nrf_assert 4.0.0-2.alpha, nRF_Libraries:nrf_log 4.0.0-2.alpha, nRF_Libraries:retarget 4.0.0-2.alpha, nRF_Libraries:segger_rtt 1.2.1-2.alpha, nRF_NFC:hal_nfc 1.0.0-2.alpha, nRF_NFC:hal_nfc_logger_universal 1.0.0-2.alpha, nRF_NFC:nfc_ac_rec 1.0.0-2.alpha, nRF_NFC:nfc_hs_rec 1.0.0-2.alpha, nRF_NFC:nfc_lib 1.0.0-2.alpha, nRF_NFC:nfc_ndef_msg 1.0.0-2.alpha, nRF_NFC:nfc_ndef_record 1.0.0-2.alpha, nRF_NFC:nfc_uri_msg 1.0.0-2.alpha, nRF_NFC:nfc_uri_rec 1.0.0-2.alpha
